# Keil uVision project STM32F407_ProjectTemplate.uvprojx, settings and files
target ProjectTemplate (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407_ProjectTemplate +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__TARGET_FPU_VFP,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\Common;..\Startup_config;..\STM32F4_FWLIB\inc;..\USER\inc;..\DSP_LIB;..\DSP_LIB\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Common
    ../Common/: common.c
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_i2c.c
  group USER
    ../USER/src/: adc.c dac.c dma.c spi.c timer.c uart.c lcd.c i2c.c w25qxx.c led.c key.c pid.c touch.c xpt2046.c convolution.c math_helper.c GPIO.c pwm.c arm_cmsis_dsp.c AD9833.c fft.c freqmeas.c dac7612.c
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
    ../DSP_LIB/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h
